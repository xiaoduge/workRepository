# Keil uVision project Project.uvproj, settings and files
target Resistivity Measurement V0.0.1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\USER\SysTick;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\LCM12232B;..\USER\SN74ALVC164245;..\USER\GT21L16S2W;..\USER\PCF8563;..\USER\24LC01B;..\USER\Peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h APP_CodeConversion.c APP_WDC.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../: readme.txt
  group SysTick
    ../USER/SysTick/: stm32f10x_systick.c systick.c
  group APP
    ../USER/PCF8563/: APP_PCF8563.c
    ../USER/24LC01B/: APP_24LC01B.c
    ../USER/LCM12232B/: APP_LCM12232B.c
    ../USER/SN74ALVC164245/: APP_SN74ALVC164245.c
    ../USER/GT21L16S2W/: APP_GT21L16S2W.c
  group Peripheral
    ../USER/Peripheral/: APP_Key.c APP_DO.c APP_LED.c APP_DI.c
